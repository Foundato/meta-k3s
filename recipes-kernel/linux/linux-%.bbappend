FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://k3smodules.cfg"